# Base this image on core-image-minimal-dev
require recipes-core/images/core-image-minimal-dev.bb

include include/tqs-default-features.inc
