# Base this image on core-image-minimal
require recipes-core/images/core-image-minimal.bb

include include/tqs-default-features.inc
