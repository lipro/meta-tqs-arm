include udev-legacy.inc

PR = "r0"

# module-init-tools from kmod_git will provide libkmod runtime
# have to evaluate: DEPENDS += "module-init-tools"

SRC_URI[md5sum] = "bd122d04cf758441f498aad0169a454f"
SRC_URI[sha256sum] = "b8959cc951ff69ff13305aad6836eac1ff672d98d5a11435c38c4608f77bbd6a"
