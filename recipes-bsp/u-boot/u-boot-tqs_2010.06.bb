# Adapted from linux-imx.inc, copyright (C) 2013 Li-Pro.Net
# Released under the MIT license (see COPYING.MIT for the terms)

include u-boot-tqs.inc

COMPATIBLE_MACHINE = "(tqma35)"

# U-Boot version and SRCREV correspond to:
# github.com/lipro v2010.06-tqma35-0105 tag
UBOOT_VERSION = "2010.06"
UBOOT_VERSION_EXTENSION = "-tqma35-0105"
SRCREV = "4faae1c148db9a9d3d64e0104b627095c385f126"
